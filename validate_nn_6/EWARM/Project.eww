<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\validate_nn_6.ewp</path>
  </project>
  <batchBuild />
</workspace>
